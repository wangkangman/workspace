# Keil uVision project ROLLDOOR_BLD.uvproj, settings and files
target ROLLDOOR_BLD (ARM-ADS)
  device: NUC029LAN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: ROLLDOOR_BLD +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\Source\globals;.\Source\drivers;.\Source\etapps
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='starts.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group globals
    ./Source/globals/: global.h regdef.h global.c
  group etapps
    ./Source/etapps/: main.c main.h subs.c subs.h
  group drivers
    ./Source/drivers/: clkrst.c clkrst.h uartct.c uartct.h timwdt.c timwdt.h ledseg.c ledseg.h keysmp.c keysmp.h adcsmp.c adcsmp.h flashs.c flashs.h
  group startup
    ./Source/startup/: starts.s
