# Keil uVision project ROLLDOOR_APP.uvproj, settings and files
target ROLLDOOR_APP (ARM-ADS)
  device: NUC029LAN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: ROLLDOOR_APP +hex
  AfterMake: fromelf --bin "Objects\GD50D01_APP.axf" --output "Objects\GD50D01_APP.bin"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c include: .\Source\globals;.\Source\drivers;.\Source\etapps
  library: MicroLIB
  memory RVCT4: ROM 0x2000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='starts.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group globals
    ./Source/globals/: global.h regdef.h global.c debug.h errlist.h
  group etapps
    ./Source/etapps/: main.c main.h subs.c subs.h
  group drivers
    ./Source/drivers/: clkrst.c clkrst.h uartct.c uartct.h timwdt.c timwdt.h motors.c motors.h remote.c remote.h keysmp.c keysmp.h adcsmp.c adcsmp.h dflash.c dflash.h ledbuzlamp.c ledbuzlamp.h pwm_capture.c pwm_capture.h config_get.c config_get.h
  group startup
    ./Source/startup/: starts.s
